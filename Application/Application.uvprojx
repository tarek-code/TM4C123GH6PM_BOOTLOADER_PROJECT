# Keil uVision project Application.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Application
  AfterMake: fromelf.exe --bin --output=Application/Application.bin D:\Tiva\TM4C123GH6PM_BOOTLOADER_PROJECT\Application\Objects\Application.axf
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x3000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: app.c button.c gpio.c sysclockcfg.c button.h gpio.h sysclockcfg.h atomic.h croutine.c croutine.h deprecated_definitions.h event_groups.c event_groups.h FreeRTOS.h list.c list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h port.c portable.h portmacro.h projdefs.h queue.c queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.c stream_buffer.h task.h tasks.c timers.c timers.h FreeRTOSConfig.h heap_4.c app.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.1
